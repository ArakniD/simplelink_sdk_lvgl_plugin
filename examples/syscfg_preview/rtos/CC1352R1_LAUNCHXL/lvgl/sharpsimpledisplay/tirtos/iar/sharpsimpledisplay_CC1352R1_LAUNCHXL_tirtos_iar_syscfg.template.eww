<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sharpsimpledisplay_CC1352R1_LAUNCHXL_tirtos_iar_syscfg.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1352R1_LAUNCHXL/release/iar/tirtos_builds_CC1352R1_LAUNCHXL_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>